# Repository loptienm/FishLight_PCB

File README.md:

FishLight\_PCB: A custom PCB for the FishLight project.

Created by Mike Loptien in 2013 in Longmont Colorado
=========

This is a custom PCB design for the FishLight project.  This started out as a simple board using an Arduino to control the brightness of the LEDs I am using for my fishtank.  However, it has quickly grown into an all around fishtank control system.  It has the ability to turn on and off the LEDs, monitor each string's power usage, adjust the amount of current being supplied to each string, turn on and off a number of 12V and AC devices (such as solenoids, pumps, fans, heaters, filters, etc.), monitor temperature of the board and the fishtank, conduct automatic water changes and top-offs, and connect to the internet using a Spark Core instead of arduino.

## EAGLE design FishLight-v01.brd

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C13, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43: 0.1uF; 0603-CAP
C12, C14: 0.33uF; 0603-CAP
FRAME1, FRAME2: FRAME-LETTER; CREATIVE_COMMONS
JP1, JP2: DS18B20EXT; MOLEX-1X3
JP4, JP5: M03POLAR; MOLEX-1X3
JP6, JP7, JP17, JP19, JP21, JP22, JP23, JP24, JP25, JP26, JP27, JP28, JP30, JP31, JP32: M023.5MM; SCREWTERMINAL-3.5MM-2
JP8, JP13, JP14, JP15: M01PTH; 1X01
JP9, JP10, JP11, JP12, JP16, JP20: M03SCREW; SCREWTERMINAL-3.5MM-3
JP18: M05POLAR; MOLEX-1X5
JP29, JP33, JP34: M02POLAR; MOLEX-1X2
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13: LED0603; LED-0603
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15: RK7002BSOT23-3; SOT-23-3
R1, R2, R4, R58, R59, R60, R61: 4.7K; 0603-RES
R3, R5, R18, R21, R24, R27, R30, R33, R36, R39, R42, R45, R48, R51, R54, R55, R56, R57: 10K; 0603-RES
R6, R7, R8, R9, R10, R13, R14, R15: 0.1; R2010
R11, R12, R17, R20, R23, R26, R29, R32, R35, R38, R41, R44, R47, R50, R53: 330; 0603-RES
R16, R19, R22, R25, R28, R31, R34, R37, R40, R43, R46, R49, R52: 150; 0603-RES
STANDOFF1, STANDOFF2, STANDOFF3, STANDOFF4: STAND-OFF
U1: SPARK_CORECORE; SPARK_CORE
U3, U4, U5, U6, U7, U23, U24, U25: CAT4101TO-263; TO-263
U8, U9, U10, U22: AD5248MSOP-10; MSOP-10
U11, U12, U13, U14, U15, U26, U27, U28: INA219SOT23-8; SOT23-8
U16: MIC29300TO-263-3; TO-263-3
U17: L7805TO-252-3; TO-252-3
U29, U30: CD74HC4067SSOP24; SSOP24
U31, U32, U33: RELAY-SOLIDSTATEPTH; RELAY-S108T02
U34, U35, U36, U37, U38, U39, U40, U41, U42, U43, U44, U45, U46, U47, U48: NC7SZ373TSSOP-6; TSSOP-6
U49: DS18B20USOP8; USOP8

Connections:
3.3A: U1.22 (VDDA)
3.3V: U1.24 (VCC)
5V: C1.1, C2.1, C3.1, C4.1, C5.1, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C15.1, C16.2, C17.2, C18.2, C19.1, C20.1, C21.1, C22.2, C23.2, C24.2, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, JP1.3 (VDD), JP2.3 (VDD), JP8.1, JP18.4, LED1.A, LED2.A, LED3.A, LED4.A, LED5.A, LED6.A, LED7.A, LED8.A, LED9.A, LED10.A, LED11.A, LED12.A, LED13.A, R1.2, R2.2, R4.2, R55.1, R56.1, R57.1, R58.2, R59.2, R60.2, R61.2, U1.1 (RAW), U3.2 (VIN), U4.2 (VIN), U5.2 (VIN), U6.2 (VIN), U7.2 (VIN), U8.5 (VDD), U9.5 (VDD), U9.8 (AD1), U10.2 (AD0), U10.5 (VDD), U11.4 (VDD), U12.4 (VDD), U12.7 (A0)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
12V: C6.1, JP4.2, JP5.2, JP15.1, JP17.1, JP19.1, JP21.1, JP22.1, JP23.1, JP24.1, JP25.1, JP26.1, JP27.1, JP28.1, U16.3 (OUT)
24V: C12.1, C14.1, JP6.1, JP6.2, JP13.1, R6.2, R7.2, R8.2, R9.2, R10.2, R13.2, R14.2, R15.2, U11.1 (V+), U12.1 (V+), U13.1 (V+), U14.1 (V+), U15.1 (V+), U16.1 (IN), U17.1 (IN), U26.1 (V+), U27.1 (V+), U28.1 (V+)
A0: U1.12 (A0), U3.1 (PWM), U7.1 (PWM)
A1: U1.11 (A1), U5.1 (PWM), U25.1 (PWM)
A2: U1.10 (A2), U4.1 (PWM), U23.1 (PWM)
A3: U1.9 (A3), U6.1 (PWM), U24.1 (PWM)
A4: JP29.2, U1.8 (A4)
A5: JP33.2, U1.7 (A5)
A6: JP34.2, U1.6 (A6)
D2: U1.15 (D2), U29.10 (S0), U30.10 (S0)
D3: U1.16 (D3), U29.11 (S1), U30.11 (S1)
D4: U1.17 (D4), U29.14 (S2), U30.14 (S2)
D5: U1.18 (D5), U29.13 (S3), U30.13 (S3)
D6: JP1.2 (DQ), JP2.2 (DQ), R4.1, U1.19 (D6), U49.P$1 (DQ)
DC2: JP19.2, Q1.3 (D)
DC3: JP21.2, Q2.3 (D)
DC4: JP24.2, Q3.3 (D)
DC5: JP25.2, Q4.3 (D)
DC6: JP27.2, Q5.3 (D)
DC7: JP28.2, Q6.3 (D)
DC8: JP26.2, Q7.3 (D)
DC9: JP23.2, Q8.3 (D)
DC10: JP22.2, Q9.3 (D)
DC11: JP17.2, Q10.3 (D)
DC12: Q11.3 (D), U31.4 (-)
DC13: Q12.3 (D), U32.4 (-)
DC14: Q13.3 (D), U33.4 (-)
DCOM: U1.5 (A7), U30.1 (COM)
DL0: U30.21 (I10), U44.3 (D)
DL1: U30.22 (I9), U45.3 (D)
DL2: U30.6 (I3), U34.3 (D)
DL3: U30.5 (I4), U35.3 (D)
DL4: U30.4 (I5), U36.3 (D)
DL5: U30.3 (I6), U37.3 (D)
DL6: U30.2 (I7), U38.3 (D)
DL7: U30.19 (I12), U39.3 (D)
DL8: U30.18 (I13), U40.3 (D)
DL9: U30.16 (I15), U41.3 (D)
DL10: U30.17 (I14), U42.3 (D)
DL11: U30.20 (I11), U43.3 (D)
DL12: U30.23 (I8), U48.3 (D)
DL13: U30.7 (I2), U47.3 (D)
DL14: U30.9 (I0), U46.3 (D)
ECOM: U1.20 (D7), U29.1 (COM)
FAN1: R3.2, R11.2, U44.4 (Q)
FAN2: R5.2, R12.2, U45.4 (Q)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.1, C10.1, C11.1, C12.2, C13.1, C14.2, C15.2, C16.1, C17.1, C18.1, C19.2, C20.2, C21.2, C22.1, C23.1, C24.1, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, JP1.1 (GND), JP2.1 (GND), JP7.1, JP7.2, JP14.1, JP18.3, JP29.1, JP33.1, JP34.1, Q1.1 (S), Q2.1 (S), Q3.1 (S), Q4.1 (S), Q5.1 (S), Q6.1 (S), Q7.1 (S), Q8.1 (S), Q9.1 (S), Q10.1 (S), Q11.1 (S), Q12.1 (S), Q13.1 (S), Q14.1 (S), Q15.1 (S), R3.1, R5.1, R18.1, R21.1, R24.1, R27.1, R30.1, R33.1, R36.1, R39.1, R42.1, R45.1, R48.1, R51.1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
LE0: U29.9 (I0), U44.1 (LE)
LE1: U29.23 (I8), U45.1 (LE)
LE2: U29.16 (I15), U34.1 (LE)
LE3: U29.17 (I14), U35.1 (LE)
LE4: U29.18 (I13), U36.1 (LE)
LE5: U29.19 (I12), U37.1 (LE)
LE6: U29.20 (I11), U38.1 (LE)
LE7: U29.3 (I6), U39.1 (LE)
LE8: U29.4 (I5), U40.1 (LE)
LE9: U29.6 (I3), U41.1 (LE)
LE10: U29.5 (I4), U42.1 (LE)
LE11: U29.2 (I7), U43.1 (LE)
LE12: U29.22 (I9), U48.1 (LE)
LE13: U29.21 (I10), U47.1 (LE)
LE14: U29.7 (I2), U46.1 (LE)
LED1: JP20.3, R6.1, U11.2 (V-)
LED2: JP12.3, R7.1, U12.2 (V-)
LED3: JP11.1, R8.1, U13.2 (V-)
LED4: JP11.2, R9.1, U14.2 (V-)
LED5: JP12.2, R10.1, U15.2 (V-)
LED6: JP11.3, R13.1, U26.2 (V-)
LED7: JP20.2, R14.1, U27.2 (V-)
LED8: JP12.1, R15.1, U28.2 (V-)
LG1: JP16.1, U3.5 (LED)
LG2: JP9.2, U4.5 (LED)
LG3: JP10.3, U5.5 (LED)
LG4: JP10.1, U6.5 (LED)
LG5: JP9.1, U7.5 (LED)
LG6: JP10.2, U23.5 (LED)
LG7: JP16.2, U25.5 (LED)
LG8: JP9.3, U24.5 (LED)
LR1: U3.4 (RSET), U8.3 (W2)
LR2: U4.4 (RSET), U8.10 (W1)
LR3: U5.4 (RSET), U9.3 (W2)
LR4: U6.4 (RSET), U9.10 (W1)
LR5: U7.4 (RSET), U10.3 (W2)
LR6: U10.10 (W1), U23.4 (RSET)
LR7: U22.3 (W2), U25.4 (RSET)
LR8: U22.10 (W1), U24.4 (RSET)
unnamed: Q14.2 (G), R11.1
unnamed: Q1.2 (G), R16.2, R17.1
unnamed: Q15.2 (G), R12.1
unnamed: JP4.1, Q14.3 (D)
unnamed: JP5.1, Q15.3 (D)
unnamed: Q2.2 (G), R19.2, R20.1
unnamed: R20.2, R21.2, U35.4 (Q)
unnamed: R55.2, U31.3 (+)
unnamed: LED2.C, R19.1
unnamed: R56.2, U32.3 (+)
unnamed: R57.2, U33.3 (+)
unnamed: Q3.2 (G), R22.2, R23.1
unnamed: R23.2, R24.2, U36.4 (Q)
unnamed: LED3.C, R22.1
unnamed: R17.2, R18.2, U34.4 (Q)
unnamed: Q4.2 (G), R25.2, R26.1
unnamed: Q10.2 (G), R28.2, R29.1
unnamed: R26.2, R27.2, U37.4 (Q)
unnamed: LED4.C, R25.1
unnamed: R29.2, R30.2, U43.4 (Q)
unnamed: LED5.C, R28.1
unnamed: Q9.2 (G), R31.2, R32.1
unnamed: R32.2, R33.2, U42.4 (Q)
unnamed: LED6.C, R31.1
unnamed: LED1.C, R16.1
unnamed: Q8.2 (G), R34.2, R35.1
unnamed: R35.2, R36.2, U41.4 (Q)
unnamed: LED7.C, R34.1
unnamed: Q7.2 (G), R37.2, R38.1
unnamed: R38.2, R39.2, U40.4 (Q)
unnamed: LED8.C, R37.1
unnamed: Q5.2 (G), R40.2, R41.1
unnamed: R41.2, R42.2, U38.4 (Q)
unnamed: LED9.C, R40.1
unnamed: JP30.1, U33.1 (T1)
unnamed: JP30.2, U33.2 (T2)
unnamed: JP31.1, U31.1 (T1)
unnamed: JP31.2, U31.2 (T2)
unnamed: JP32.1, U32.1 (T1)
unnamed: JP32.2, U32.2 (T2)
unnamed: Q6.2 (G), R43.2, R44.1
unnamed: R44.2, R45.2, U39.4 (Q)
unnamed: LED10.C, R43.1
unnamed: Q11.2 (G), R46.2, R47.1
unnamed: R47.2, R48.2, U48.4 (Q)
unnamed: LED11.C, R46.1
unnamed: Q12.2 (G), R49.2, R50.1
unnamed: R50.2, R51.2, U47.4 (Q)
unnamed: LED12.C, R49.1
unnamed: Q13.2 (G), R52.2, R53.1
unnamed: R53.2, R54.2, U46.4 (Q)
unnamed: LED13.C, R52.1
RES: JP18.5, U1.23 (!RST)
SCL: JP18.1, R2.1, R59.1, R61.1, U1.14 (D1), U8.6 (SCL), U9.6 (SCL), U10.6 (SCL), U11.5 (SCL), U12.5 (SCL), U13.5 (SCL), U14.5 (SCL), U15.5 (SCL), U22.6 (SCL), U26.5 (SCL), U27.5 (SCL), U28.5 (SCL)
SDA: JP18.2, R1.1, R58.1, R60.1, U1.13 (D0), U8.7 (SDA), U9.7 (SDA), U10.7 (SDA), U11.6 (SDA), U12.6 (SDA), U13.6 (SDA), U13.7 (A0), U14.6 (SDA), U14.8 (A1), U15.6 (SDA), U22.7 (SDA), U26.6 (SDA), U27.6 (SDA), U27.7 (A0), U28.6 (SDA), U28.7 (A0), U28.8 (A1)

Notes on the sheet:
Onboard / External TMP Sensors
Screw Terminals
I-sense
ADR: 00
ADR: 01
ADR: 10
ADR: 1000
ADR: 100
Fan Connectors
Screws
WW2
ADR: 11
BL2
RD2
CW2
ADR: 101
ADR: 110
ADR: 1010
PWM
12V Devs
D input to Flip Flop
LE input to Flip Flop (clock)
AC Devs
Fans
LED: 2.2V, 20mA
Water Level Sensors
Pots
Note: Add pullups on Spark Core pins in software

Board: 2 copper layers, 83.8 x 83.8 mm, 215 parts (113 on the bottom side), 142 nets.

Other parts of the board:
U$1: SPARK_LOGO2

## Commit log (part)

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2013-04-17 FishLight_PCB: Initial commit of git stuff
    First commit for the git stuff.
2013-04-17 FishLight_PCB: First rev of schematic and board
    These are the preliminary commits of the FishLight_PCB schematic and
    layout. They are rudimentary and essentially just set up the
    mechanicals for the board to fit nicely onto the heatsink, Also put
    down the Arduino and RTC because they are rather large. I'm not sure
    what the .b#* files are but they seem to be autogenerated. So
    committing them as well.
2013-09-18 FishLight_PCB: Updated my parts library
    Updated my RTC breakout board and my Arduino Shield Flipped symbols to
    be more visually appealing and better reflect the size of the parts they
    represent.
2013-09-18 Fishlight_PCB: Updated the schematic and layout
    Updated the schematic and layout to add power and ground planes and to
    swap out my old parts for my updated library parts.
2013-09-22 FishLight_PCB: Connected screw terminals
    Connected the screw terminals to the Arduino so that each Arduino pin
    has a terminal. Rearranged the schematic a bit to be more organized and
    also added LED screw terminals.
2013-10-01 FishLight_PCB: Added CAT4101
    Created a symbol and layout for the CAT4101 device. Hooked up the power
    and ground pins with a bypass cap and connected the PWM pins. Also
    added pull ups for the I2C bus.
2013-10-01 FishLight_PCB: Added CD74HC4067 16x MUX
    Added the CD74HC4067 16-Channel MUX. This is going to control which
    digital pot gets written to since they all have the same I2C address. I
    hope it will be fast enough to write a single register on each pot.
    Pulled the SSOP20 package from Sparkfun and modified it for a 24 pin
    package. Hooked up the SDA signals on 3 of the pots and the Arduino.
    Still need to connect the Digital control signals S0-3. Need to choose
2013-10-08 FishLight_PCB: Added 12V regulator
    Added the UA7812 12V regulator. This will convert my 24V power supply
    to 12V to power the Arduino. This may also power a fan.
2013-10-11 FishLight_PCB: Upgrade to Spark Core
    I am planning on using the Spark Core for this project so that I can
    have a wireless connection to program the board and get updates on
    things like temperature wirelessly. Added the Spark Core parts library,
    the Adafruit parts library, updated a few of my parts and changed to the
    Spark Core.
2013-10-12 FishLight_PCB: Some minor edits
    Added pull up resistors on the external temperature sensor headers.
    Changed some text.
2013-10-15 FishLight_PCB: Added the AD5248 digital pot symbol
    Added the AD5248 digital potentiometer. This pot has 2 circuits and 2
    address pins. By getting 3 of these parts, I will be able to
    individually select each LED channels current limit with 1 extra
    potentiometer without having to use a MUX. This saves space, potential
    noise issues, and some cost. I have not yet added this pot to the
    schematic, only to the library.
2013-10-15 FishLight_PCB: Connected the AD5248
    Replaced the existing potentiometers with the AD5248. Set addresses 00,
    01, and 10.
2013-10-15 FishLight_PCB: Added INA219 current sensor
    Added the INA219 current sensor. This will make sure that I am driving
    the LEDs with the amount of current I am expecting. I can also use this
    to hone in on my potentiometer settings. These are removable if the
    board gets too crowded.
2013-10-18 FishLight_PCB: Added power headers
    Added some single pin headers for the power rails. Also moved
    the current sensing resistors to the back of the board.
    Hopefully this will help me route the control signals a little
    easier.
2013-10-18 FishLight_PCB: Start wires for current sensor
    Started routing some wires for the 24V rail and the current sense
    components. There is a very large 24V trace and some vias connecting
    the resistors on the bottom to the sensor on the top.
2013-10-25 FishLight_PCB: Added Red and Green labels
    Added Red and Green text labels to the extra CAT4101s.
2013-10-25 FishLight_PCB: Fixed fan transistors
    Fixed the fan connector transistor pull down resistors. These were
    connected to drain but they need to be connected to gate so that the
    transistor shuts off correctly. Also added some Solid State Relays to
    possibly turn on and off some AC loads (such as a pump or the heater)
    for emergency situations. These will probably go away though. Kind of
    an interesting idea is all.
2013-11-30 FishLight_PCB: Moved Current Sensor resistor vias
    The Vias that connect the current sensor resistors to the top layer were
    not centered very well on their pads. This should help to distribute
    the current a bit better.
2013-11-30 FishLight_PCB: Add NC7SZ373 D-Latch
    The NC7SZ373 is a D-Latch which can be used to turn on and off a device
    with a transistor attached by setting 'D" to on/off and then pulsing the
    'LE' input. This will require 2 pins, D and LE and 2 muxes which
    correspond to these inputs. Possibly only 1 mux if I use less than 7
    devices on a 4 - 15 mux.
2013-12-01 FishLight_PCB: Add DS3231M and rearrange board
    Added the DS3231M RTC with on-board oscillator and I2C interface. Also
    rearranged the board a bit and placed the extra LED string parts in a
    reasonable location (CAT4101s, I-sense, etc). Also added a battery
    holder for the RTC. Hopefully using my own RTC instead of the breakout
    board will save some space.
2013-12-01 FishLight_PCB: Replaced the RTC and added VIAs
    Replaced the giant RTC breakout board with the new DS3231M RTC. This
    can fit right under the Spark Core so it takes up very little space.
    The battery is still kinda big but its not a big deal. Also added VIAs
    to the CAT4101s that are on the top side and to the I-Sense resistors
    that are new.
2013-12-11 FishLight_PCB: Shrink schematic symbols
    In an effort to save space, I have shrunk many of my own schematic
    symbols by making pins small instead of medium in their properties.
    This saved a lot of space in the schematic. I also added 9 2pin screw
    terminals for 12V devices and changed the current limiting resistor on
    the fans to limit current to the transistor, not the fan itself. I may
    also put some LEDs on the 12V devices and the SSRs in order to show what
2013-12-30 FishLight_PCB: Add second SCH frame and replace 12V reg
    Added a second Schematic frame and placed it in a place that will allow
    it to be printed correctly. This will open up a lot of room for more
    devices on my schematic, specifically my 12V devices. Also changed my
    12V regulator to a higher current (3A) version. This will allow me to
    have more 12V devices. Also added 3 more, total 5, SSRs. This may be
    too many for my case but it will be interesting to try it out.
2013-12-30 FishLight_PCB: Started work on 12V devices
    The 12V devices require the ability to turn them on and off but also to
    hold them on or off without constant need of the Spark Core to supply a
    transistor. I am going to use a MUX with a D Flip-Flop and a transistor
    to hold the devices High or Low and then go and do other things while
    the FF holds their state. I have placed the MUXes, the beginnings of
    the FF circuit, and the terminals. I have also connected the Spark
2013-12-30 FishLight_PCB: Update D-Latch symbol
    The D-Latch symbol was really big. I was able to make it a bit smaller
    so that I could fit a bunch of these circuits onto the schematic.
2013-12-30 FishLight_PCB: Finish 12V and AC devices
    The AC and 12V devices control circuitry is finished. Now to just place
    the parts and start laying them out. Also made sure to include enough
    decoupling caps for all 17 new parts.
2013-12-30 FishLight_PCB: Resized the board
    The board was an awkward size and shape. Resized it to be squarer and a
    more useful size.
2013-12-30 FishLight_PCB: Started trying to layout 12V devices
    Started placing parts for the 12V devices. This is going to be very
    difficult. The power circuits are pretty large and may get pretty
    jumbled up. Just need a very good placement so that routing doesn't get
    too crazy.
2014-01-03 FishLight_PCB: Rearranged some parts
    Rearranged the CAT4101s to make more room. Also changed their screw
    terminal assignments to limit the number of crossings. This will have
    to be resolved in software now because the screw terminal assignments
    are all screwed around. Also changed around the Spark to make more room
    for the AC SSRs. These are now placed on the board. Also moved around
    the 12V devices screw terminals and circuitry to limit MUX crossings.
2014-01-04 FishLight_PCB: Add a README.md file
    Adding a README.
2014-01-22 FishLight_PCB: Routed power lines and sized them right
    Moved a few things around and then routed the power lines for the
    12V and 24V lines. Also sized them appropriately for their max
    current of about 7A and 15A respectively.
2014-02-03 FishLight_PCB: Place bypass caps and move stuff
    Placed the bypass caps for each device and then moved some things around
    to make more room as needed. Also correctly linked the Sparkfun and
    Adafruit libraries so that I could change footprints and stuff.
2014-03-24 FishLight_PCB: Lots of changes
    Updated the package for the AD5248 digital potentiometers so that the
    pins do not cause DRC errors. Also continued routing and moved around
    the LED ground connections so that they would be easier to use. Also
    changed the address assignments for the INA219 current sensors so that
    they would be easier to route. Did a DRC check and approved a number of
    overlaps. I also made a few attempts at putting in flyback diodes but
2014-03-24 FishLight_PCB: Removed flyback diodes
    I forgot to remove these before so I am removing them now.
2014-07-06 FishLight_PCB: Changed 12V connectors
    The old connectors were 2.54mm. Changed to 3.5mm because they are
    bigger, easier to use, and not as ugly either. Also moved some
    things around in order to get them to fit.
2014-07-06 FishLight_PCB: Did a lot of routing
    Routed a bunch of signals. Got the entire lower half of the board done,
    now pretty much just need to do the 12V and AC devices and it is done.
2014-07-11 FishLight_PCB: Lots and lots of routing
    Most of the routing is done now. Got the MUX signals mostly figured out
    but there are still a few that are going to be very tough, like the AC
    devices and the fans. The AC devices still need to be hooked to their
    terminals too and this worries me because there isn't much space to
    isolate the lines. I guess the good news is that if it shorts that just
    means it gets connected and it wont be controllable from the Spark. But
2014-07-13 FishLight_PCB: Finished routing
    Finished routing the board! Now just to do some cleanup and maybe add
    some pull up resistors to the ends of the I2C strings. They are pretty
    long and could have difficulty driving to the ends.
2014-09-13 FishLight_PCB: Checked and updated footprints
    Checked all device footprints and found a few to be incorrect. I
    updated these and have double checked them. This is now ready to be
    manufactured.

Notices in the files:
parts and their libraries:
SparkFun-Electromechanical: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
SparkFun-Aesthetics: Released under the Creative Commons Attribution Share-Alike 4.0 License
SparkFun-Aesthetics: https://creativecommons.org/licenses/by-sa/4.0
